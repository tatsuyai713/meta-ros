DESCRIPTION = "Utilities for flashing and enabling Kobuki's USB connection."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-command-line libusb1 libftdi"

require kobuki-core.inc
