DESCRIPTION = "Driver for iRobot Create and Roomba"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=58e54c03ca7f821dd3967e2a2cd1596e"

require turtlebot-create.inc
